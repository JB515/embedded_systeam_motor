# Keil uVision project ES_CW2_Starter.uvprojx, settings and files
target ES_CW2_Starter (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F303K8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.4.0
  output: ES_CW2_Starter
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD --preinclude=mbed_config.h -DRTC_LSI=1 -D__ASSERT_MSG -DTARGET_RELEASE --no_rtti -Otime -DDEVICE_PORTINOUT=1 -DDEVICE_PWMOUT=1 -DDEVICE_I2C_ASYNCH=1 -DTARGET_FF_ARDUINO -c -DTARGET_RTOS_M4_M7 -O3 -DDEVICE_CAN=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 --split_sections -DDEVICE_SERIAL_FC=1 -DMBED_BUILD_TIMESTAMP=1489049759.93 --cpu=Cortex-M4.fp -DDEVICE_SERIAL=1 -DDEVICE_ANALOGIN=1 -DTARGET_LIKE_CORTEX_M4 -D__CORTEX_M4 -DTARGET_CORTEX_M -DTARGET_NUCLEO_F303K8 -DARM_MATH_CM4 -DDEVICE_I2C=1 -DDEVICE_PORTIN=1 -DDEVICE_LOWPOWERTIMER=1 -DTARGET_STM32F303K8 -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DTARGET_STM -DTARGET_LIKE_MBED --gnu --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SPISLAVE=1 -DTARGET_M4 -D__FPU_PRESENT=1 -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DDEVICE_SPI_ASYNCH=1 -DTRANSACTION_QUEUE_SIZE_SPI=2 -D__MBED_CMSIS_RTOS_CM -DTARGET_STM32F3
  c include: .; mbed-os/.; mbed-os/docs; mbed-os/features; mbed-os/features/frameworks; mbed-os/features/frameworks/greentea-client; mbed-os/features/frameworks/greentea-client/greentea-client; mbed-os/features/frameworks/greentea-client/source; mbed-os/features/frameworks/unity; mbed-os/features/frameworks/unity/source; mbed-os/features/frameworks/unity/unity; mbed-os/features/frameworks/utest; mbed-os/features/frameworks/utest/source; mbed-os/features/frameworks/utest/utest; mbed-os/features/mbedtls; mbed-os/features/mbedtls/importer; mbed-os/features/mbedtls/inc; mbed-os/features/mbedtls/inc/mbedtls; mbed-os/features/mbedtls/src; mbed-os/features/mbedtls/platform; mbed-os/features/mbedtls/platform/inc; mbed-os/features/mbedtls/platform/src; mbed-os/features/nanostack; mbed-os/features/storage; mbed-os/features/netsocket; mbed-os/cmsis; mbed-os/drivers; mbed-os/events; mbed-os/events/equeue; mbed-os/rtos; mbed-os/rtos/rtx; mbed-os/rtos/rtx/TARGET_CORTEX_M; mbed-os/rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7; mbed-os/rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7/TOOLCHAIN_ARM; mbed-os/hal; mbed-os/hal/storage_abstraction; mbed-os/platform; mbed-os/targets; mbed-os/targets/TARGET_STM; mbed-os/targets/TARGET_STM/TARGET_STM32F3; mbed-os/targets/TARGET_STM/TARGET_STM32F3/TARGET_NUCLEO_F303K8; mbed-os/targets/TARGET_STM/TARGET_STM32F3/TARGET_NUCLEO_F303K8/device; mbed-os/targets/TARGET_STM/TARGET_STM32F3/TARGET_NUCLEO_F303K8/device/TOOLCHAIN_ARM_STD; mbed-os/targets/TARGET_STM/TARGET_STM32F3/device
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-DTRANSACTION_QUEUE_SIZE_SPI=2,-DRTC_LSI=1,-D__CORTEX_M4,-DARM_MATH_CM4,-D__FPU_PRESENT=1,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed-os/targets/TARGET_STM/TARGET_STM32F3/TARGET_NUCLEO_F303K8/device/TOOLCHAIN_ARM_STD/stm32f303x8.sct
  group 
    ./: mbed_config.h main.cpp
  group equeue
    mbed-os/events/equeue/: equeue.h equeue_platform.h equeue.c equeue_posix.c equeue_mbed.cpp
  group greentea-client
    mbed-os/features/frameworks/greentea-client/greentea-client/: test_env.h greentea_serial.h greentea_metrics.h
  group cmsis
    mbed-os/cmsis/: arm_common_tables.h arm_const_structs.h arm_math.h core_ca9.h core_caFunc.h core_caInstr.h core_ca_mmu.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h
  group utest
    mbed-os/features/frameworks/utest/utest/: unity_handler.h utest.h utest_case.h utest_default_handlers.h utest_harness.h utest_scheduler.h utest_serial.h utest_shim.h utest_specification.h utest_stack_trace.h utest_types.h
    mbed-os/features/frameworks/utest/: mbed-utest-shim.cpp
  group TARGET_STM32F3
    mbed-os/targets/TARGET_STM/TARGET_STM32F3/: PeripheralPins.h common_objects.h device.h gpio_object.h i2c_device.h analogin_api.c analogout_api.c can_api.c gpio_api.c gpio_irq_api.c mbed_overrides.c pinmap.c port_api.c pwmout_api.c serial_api.c spi_api.c
  group mbedtls
    mbed-os/features/mbedtls/inc/mbedtls/: aes.h aesni.h arc4.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h check_config.h cipher.h cipher_internal.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h entropy_poll.h error.h gcm.h havege.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h ripemd160.h rsa.h sha1.h sha256.h sha512.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h cmac.h config-no-entropy.h net_sockets.h platform_time.h ssl.h
  group inc
    mbed-os/features/mbedtls/platform/inc/: platform_mbed.h
  group hal
    mbed-os/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h ethernet_api.h gpio_api.h gpio_irq_api.h emac_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h mbed_gpio.c mbed_lp_ticker_api.c mbed_pinmap_common.c mbed_ticker_api.c mbed_us_ticker_api.c
  group netsocket
    mbed-os/features/netsocket/: CellularInterface.h EthInterface.h MeshInterface.h NetworkInterface.h NetworkStack.h Socket.h SocketAddress.h TCPServer.h TCPSocket.h UDPSocket.h WiFiAccessPoint.h WiFiInterface.h emac_stack_mem.h nsapi.h nsapi_dns.h nsapi_types.h NetworkInterface.cpp NetworkStack.cpp Socket.cpp SocketAddress.cpp TCPServer.cpp TCPSocket.cpp UDPSocket.cpp WiFiAccessPoint.cpp nsapi_dns.cpp
  group TARGET_CORTEX_M
    mbed-os/rtos/rtx/TARGET_CORTEX_M/: RTX_CM_lib.h RTX_Config.h cmsis_os.h rt_Event.h rt_HAL_CM.h rt_List.h rt_Mailbox.h rt_MemBox.h rt_Memory.h rt_Mutex.h rt_OsEventObserver.h rt_Robin.h rt_Semaphore.h rt_System.h rt_Task.h rt_Time.h rt_Timer.h rt_TypeDef.h HAL_CM.c RTX_Conf_CM.c rt_CMSIS.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_OsEventObserver.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group rtos
    mbed-os/rtos/: Mail.h MemoryPool.h Mutex.h Queue.h RtosTimer.h Semaphore.h Thread.h rtos.h rtos_idle.h rtos_idle.c Mutex.cpp RtosTimer.cpp Semaphore.cpp Thread.cpp
  group platform
    mbed-os/platform/: CThunk.h CallChain.h Callback.h CircularBuffer.h FunctionPointer.h PlatformMutex.h SingletonPtr.h Transaction.h critical.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_stats.h platform.h rtc_time.h semihost_api.h toolchain.h wait_api.h mbed_preprocessor.h mbed_assert.c mbed_board.c mbed_critical.c mbed_error.c mbed_interface.c mbed_mem_trace.c mbed_semihost_api.c mbed_wait_api_no_rtos.c mbed_stats.c CallChain.cpp mbed_alloc_wrappers.cpp mbed_rtc_time.cpp mbed_wait_api_rtos.cpp retarget.cpp
  group unity
    mbed-os/features/frameworks/unity/unity/: unity.h unity_config.h unity_internals.h
  group events
    mbed-os/events/: Event.h EventQueue.h mbed_events.h EventQueue.cpp
  group mbed-os
    mbed-os/: mbed.h
  group src
    mbed-os/features/mbedtls/src/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c cmac.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c net_sockets.c sha512.c ssl_cache.c
    mbed-os/features/mbedtls/platform/src/: mbed_trng.c
  group TARGET_STM
    mbed-os/targets/TARGET_STM/: mbed_rtx.h rtc_api_hal.h stm_spi_api.c trng_api.c hal_tick_16b.c hal_tick_32b.c i2c_api.c us_ticker_16b.c us_ticker_32b.c lp_ticker.c rtc_api.c sleep.c
  group device
    mbed-os/targets/TARGET_STM/TARGET_STM32F3/TARGET_NUCLEO_F303K8/device/: cmsis.h cmsis_nvic.h hal_tick.h stm32f303x8.h stm32f3xx.h system_stm32f3xx.h cmsis_nvic.c system_stm32f3xx.c
    mbed-os/targets/TARGET_STM/TARGET_STM32F3/device/: stm32_hal_legacy.h stm32f3xx_hal.h stm32f3xx_hal_adc.h stm32f3xx_hal_adc_ex.h stm32f3xx_hal_can.h stm32f3xx_hal_cec.h stm32f3xx_hal_comp.h stm32f3xx_hal_comp_ex.h stm32f3xx_hal_conf.h stm32f3xx_hal_cortex.h stm32f3xx_hal_crc.h stm32f3xx_hal_crc_ex.h stm32f3xx_hal_dac.h stm32f3xx_hal_dac_ex.h stm32f3xx_hal_def.h stm32f3xx_hal_dma.h stm32f3xx_hal_dma_ex.h stm32f3xx_hal_flash.h stm32f3xx_hal_flash_ex.h stm32f3xx_hal_gpio.h stm32f3xx_hal_gpio_ex.h stm32f3xx_hal_hrtim.h stm32f3xx_hal_i2c.h stm32f3xx_hal_i2c_ex.h stm32f3xx_hal_i2s.h stm32f3xx_hal_i2s_ex.h stm32f3xx_hal_irda.h stm32f3xx_hal_irda_ex.h stm32f3xx_hal_iwdg.h stm32f3xx_hal_nand.h stm32f3xx_hal_nor.h stm32f3xx_hal_opamp.h stm32f3xx_hal_opamp_ex.h stm32f3xx_hal_pccard.h stm32f3xx_hal_pcd.h stm32f3xx_hal_pcd_ex.h stm32f3xx_hal_pwr.h stm32f3xx_hal_pwr_ex.h stm32f3xx_hal_rcc.h stm32f3xx_hal_rcc_ex.h stm32f3xx_hal_rtc.h stm32f3xx_hal_rtc_ex.h stm32f3xx_hal_sdadc.h stm32f3xx_hal_smartcard.h stm32f3xx_hal_smartcard_ex.h stm32f3xx_hal_smbus.h stm32f3xx_hal_spi.h stm32f3xx_hal_spi_ex.h stm32f3xx_hal_sram.h stm32f3xx_hal_tim.h stm32f3xx_hal_tim_ex.h stm32f3xx_hal_tsc.h stm32f3xx_hal_uart.h stm32f3xx_hal_uart_ex.h stm32f3xx_hal_usart.h stm32f3xx_hal_usart_ex.h stm32f3xx_hal_wwdg.h stm32f3xx_ll_fmc.h stm32f3xx_hal.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_can.c stm32f3xx_hal_cec.c stm32f3xx_hal_comp.c stm32f3xx_hal_cortex.c stm32f3xx_hal_crc.c stm32f3xx_hal_crc_ex.c stm32f3xx_hal_dac.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_hrtim.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_i2s.c stm32f3xx_hal_i2s_ex.c stm32f3xx_hal_irda.c stm32f3xx_hal_iwdg.c stm32f3xx_hal_nand.c stm32f3xx_hal_nor.c stm32f3xx_hal_opamp.c stm32f3xx_hal_opamp_ex.c stm32f3xx_hal_pccard.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rtc.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_sdadc.c stm32f3xx_hal_smartcard.c stm32f3xx_hal_smartcard_ex.c stm32f3xx_hal_smbus.c stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_sram.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_tsc.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_usart.c stm32f3xx_hal_wwdg.c stm32f3xx_ll_fmc.c
  group TARGET_NUCLEO_F303K8
    mbed-os/targets/TARGET_STM/TARGET_STM32F3/TARGET_NUCLEO_F303K8/: PeripheralNames.h PinNames.h PortNames.h objects.h PeripheralPins.c
  group TOOLCHAIN_ARM_STD
    mbed-os/targets/TARGET_STM/TARGET_STM32F3/TARGET_NUCLEO_F303K8/device/TOOLCHAIN_ARM_STD/: startup_stm32f303x8.S sys.cpp
  group storage_abstraction
    mbed-os/hal/storage_abstraction/: Driver_Common.h Driver_Storage.h
  group source
    mbed-os/features/frameworks/unity/source/: unity.c
    mbed-os/features/frameworks/greentea-client/source/: test_env.cpp greentea_serial.cpp greentea_metrics.cpp
    mbed-os/features/frameworks/utest/source/: unity_handler.cpp utest_case.cpp utest_default_handlers.cpp utest_greentea_handlers.cpp utest_harness.cpp utest_shim.cpp utest_types.cpp utest_stack_trace.cpp
  group TOOLCHAIN_ARM
    mbed-os/rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7/TOOLCHAIN_ARM/: SVC_Table.S HAL_CM4.c
  group drivers
    mbed-os/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h SPI.h SPISlave.h Serial.h SerialBase.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h AnalogIn.cpp BusIn.cpp BusInOut.cpp BusOut.cpp CAN.cpp Ethernet.cpp FileBase.cpp FileLike.cpp FilePath.cpp FileSystemLike.cpp I2C.cpp I2CSlave.cpp InterruptIn.cpp InterruptManager.cpp LocalFileSystem.cpp RawSerial.cpp SPI.cpp SPISlave.cpp Serial.cpp SerialBase.cpp Stream.cpp Ticker.cpp Timeout.cpp Timer.cpp TimerEvent.cpp
